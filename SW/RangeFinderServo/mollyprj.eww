<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mollyprj.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwmtest1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwmtest2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rf_motor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


